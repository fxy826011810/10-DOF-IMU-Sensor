<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>

    <project><path>example-idd-lite-icm20602.ewp</path></project>

    <batchBuild/>

</workspace>