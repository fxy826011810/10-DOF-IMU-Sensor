# IAR project example-idd-lite-icm20602.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_COMPILER; __inline=inline; INV_MSG_ENABLE=INV_MSG_LEVEL_VERBOSE; ASSERT; NDEBUG; UART_DMA_MAX_TRANSF_SIZE=128; UART_DMA_BUF_TX_NR=32; INVN_DRIVERS_DEVICE_NUCLEO_REMOVE_SYS_TIMER; INVN_DRIVERS_DEVICE_NUCLEO_REMOVE_SPI_SLAVE; INVN_DRIVERS_DEVICE_NUCLEO_REMOVE_I2C_SLAVE; NUCLEO; USE_STDPERIPH_DRIVER; USE_HSE_BYPASS; HSE_VALUE=8000000; STM32F411xE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --silent; --warnings_are_errors
  ICCARM.CCIncludePath2: ../../; ../../board-hal; ../../stm32f4x/CMSIS/Core; ../../stm32f4x/CMSIS/Device; ../../stm32f4x/STM32F4xx_StdPeriph_Driver/inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example-idd-lite-icm20602.bin
  ILINK.IlinkOutputFile: example-idd-lite-icm20602.elf
  ILINK.IlinkIcfFile: stm32f411xe_flash_sector_reserved.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Headers
    ../../board-hal/: common.h dbg_gpio.h delay.h flash_linker.h flash_manager.h gpio.h i2c_master.h i2c_slave.h led.h nvic_config.h rtc_timer.h spi_master.h spi_slave.h stm32f4xx_it.h system.h sys_timer.h timer.h uart.h
    ../../stm32f4x/CMSIS/Core/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    ../../stm32f4x/CMSIS/Device/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
    ../../stm32f4x/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ../../Invn/EmbUtils/: CBinaryReader.h CBinaryWriter.h DataConverter.h ErrorHelper.h InvAssert.h InvBasicMath.h InvBits.h InvBool.h InvCksum.h InvError.h InvExport.h InvFormat.h InvList.h InvPrintf.h InvProtocol.h InvQueue.h InvScheduler.h InvString.h Logger.h Message.h RingBuffer.h RingByteBuffer.h UartTxEmulator.h
    ../../Invn/Devices/Drivers/Icm20602/: Icm20602.h Icm20602AuxCompassAkm.h Icm20602AuxTransport.h Icm20602Ctrl.h Icm20602Defs.h Icm20602SelfTest.h Icm20602Serif.h Icm20602Setup.h Icm20602Transport.h
    ../../Invn/Devices/Drivers/Ak0991x/: Ak0991x.h Ak0991xSerif.h
    ../../Invn/VSensor/../../Invn/VSensor/: VSensorConfig.h VsensorData.h
    ../../Invn/Devices/../../Invn/Devices/: SensorConfig.h SensorTypes.h
    ../../Invn/../../Invn/: IDDVersion.h InvBool.h InvError.h InvExport.h
    ../../Invn/DynamicProtocol/: DynProtocol.h DynProtocolTransport.h DynProtocolTransportUart.h
  group Sources (C)
    ./: lite_example_icm20602.c
    ../../board-hal/: common.c dbg_gpio.c delay.c flash_manager.c gpio.c i2c_master.c i2c_slave.c iar_hook.c led.c rtc_timer.c spi_master.c spi_slave.c stm32f4xx_it.c sys_timer.c timer.c uart.c
    ../../stm32f4x/CMSIS/Device/: system_stm32f4xx.c
    ../../stm32f4x/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../Invn/EmbUtils/: DataConverter.c ErrorHelper.c InvBasicMath.c InvCksum.c InvFormat.c InvList.c InvPrintf.c InvProtocol.c InvQueue.c InvScheduler.c Logger.c Message.c RingByteBuffer.c UartTxEmulator.c
    ../../Invn/Devices/Drivers/Icm20602/: Icm20602AuxCompassAkm.c Icm20602AuxTransport.c Icm20602Ctrl.c Icm20602SelfTest.c Icm20602Setup.c Icm20602Transport.c
    ../../Invn/Devices/Drivers/Ak0991x/: Ak0991x.c
    ../../Invn/Devices/../../Invn/Devices/: Sensor.c
    ../../Invn/DynamicProtocol/: DynProtocol.c DynProtocolTransportUart.c
  group Sources (ASM)
    ../../stm32f4x/CMSIS/Device/iar/: startup_stm32f411xe.S
  group Libraries
    ../../../prebuilt/lib/: libAlgoInvn.a libMLMath.a
