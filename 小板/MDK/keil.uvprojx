# Keil uVision project keil.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keil
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER
  c include: ..\Program\Core;..\Program\Icm20602;..\Program\inc;..\Program\Ist8310;..\Program\Ms5611;..\Program\System;..\Program\User;..\Program\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Src
    ../Program/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group Startup
    ../Program/Startup/: startup_stm32f40xx.s
  group System
    ../Program/System/: stm32f4xx_it.c system_stm32f4xx.c
  group Task
    ../Program/Task/: imu.c control.c ahrs.c
  group Driver
    ../Program/User/: delay.c gpio.c i2c.c nvic.c monitor.c tim.c spi.c can.c usart.c dma.c
  group Icm20602
    ../Program/Icm20602/: icm20602.c icm20602Dri.c icm20602Int.c
  group Ist8310
    ../Program/Ist8310/: ist8310.c
  group Ms5611
    ../Program/Ms5611/: ms5611.c
  group User
    ../Program/User/: main.c config.h main.h
